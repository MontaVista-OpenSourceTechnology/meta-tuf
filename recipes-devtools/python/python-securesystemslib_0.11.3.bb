inherit setuptools
require python-securesystemslib.inc

SRC_URI[md5sum] = "15eba13ba77b062e2654bd77155dcfb0"
SRC_URI[sha256sum] = "cbd1f7f1af2f2921be33b9fd17384705f5f4147d3a8b5d95b33ec3ce2213f176"

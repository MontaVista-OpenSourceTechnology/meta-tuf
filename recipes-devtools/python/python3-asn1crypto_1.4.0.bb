inherit setuptools3
require python3-asn1crypto.inc

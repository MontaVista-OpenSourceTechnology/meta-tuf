inherit pypi setuptools
require python-cryptography-vectors.inc

SRC_URI[md5sum] = "f8b166652e7a9d668b851b28e4417057"
SRC_URI[sha256sum] = "03f38115dccb266dd96538f94067442a877932c2322661bdc5bf2502c76658af"


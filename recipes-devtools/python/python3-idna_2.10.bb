inherit pypi setuptools3
require python3-idna.inc

inherit setuptools3
require python3-securesystemslib.inc

SRC_URI[md5sum] = "8513982821601d9b4667d1fb8fea06d9"
SRC_URI[sha256sum] = "de90d5a2990d2e90734166d873c4cabf5b24e7aa4a7a118acadaed11772b795e"

#SRC_URI += "file://LICENSE"

#do_patch() {
#cp ${WORKDIR}/LICENSE ${WORKDIR}/securesystemslib-0.11.3/LICENSE
#}



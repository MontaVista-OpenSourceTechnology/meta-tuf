inherit setuptools3
require python3-requests.inc

